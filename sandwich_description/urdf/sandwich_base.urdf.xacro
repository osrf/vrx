Commit message: Created sandwich skeleton

File: sandwich_description/urdf/sandwich_base.urdf.xacro (robot description, xacro)
@@ -32,2 +32,4 @@
 			<child link="$(arg namespace)/sandwich_link"/>
 		</joint>
+	</xacro:macro>
+</robot>
